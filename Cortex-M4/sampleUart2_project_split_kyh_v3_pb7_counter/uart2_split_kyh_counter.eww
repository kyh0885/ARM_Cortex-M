<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\uart2_split_kyh_counter.ewp</path>
    </project>
    <batchBuild />
</workspace>

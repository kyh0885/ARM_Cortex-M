<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sample_uart2_clcd.ewp</path>
    </project>
    <batchBuild />
</workspace>

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\uart4Test_PA2_PA3_strtok_printf.ewp</path>
    </project>
    <batchBuild />
</workspace>

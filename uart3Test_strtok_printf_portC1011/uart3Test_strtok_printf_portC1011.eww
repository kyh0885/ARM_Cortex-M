<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\uart3Test_strtok_printf_portC1011.ewp</path>
    </project>
    <batchBuild />
</workspace>

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\fnd_uart4_split.ewp</path>
    </project>
    <batchBuild />
</workspace>

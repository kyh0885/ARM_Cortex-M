<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\tim10_pwm_dcmotor_counter.ewp</path>
    </project>
    <batchBuild />
</workspace>
